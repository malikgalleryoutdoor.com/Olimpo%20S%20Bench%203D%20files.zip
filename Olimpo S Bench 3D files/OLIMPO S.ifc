Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:57:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:57:20 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{7DFE6605-CE27-4694-8157-1768F5949BDB}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:57:16 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:57:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:57:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR081 - GRANITO -733 Lt, Panca OLIMPO S:0PAAR081 - GRANITO -733 Lt:179656
In: 0 - Piano Terra
Type - Material: Acciaio, GRANITO LEVIGATO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca OLIMPO S
Type - Dati identità - BIM Name: OLIMPO S -733 Lt.; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR081; Designer: BELLITALIA DESIGN; Family Name: OLIMPO COLLECTION; Nome del tipo: 0PAAR081 - GRANITO -733 Lt; URL Eng: https://www.bellitalia.net/en/products/planters/olimpo/; URL Ita: https://www.bellitalia.net/prodotti/fioriere/olimpo/
Type - Dimensioni - Dimensions: H 880 mm X h 480 mm x ⌀ 2500 mm x r 520 mm R 1250 mm
Type - Generale - Accessori: Contenitore interno in acciaio zincato; Accessories: Inner container in galvanized steel; Descrizione Tecnica Famiglia: "Panca mod. “OLIMPO S” costituita da una seduta circolare monolitica dotata di schienale con foro passante centrale per la predisposizione non solo di fiori ma anche di piante con fusto. All’interno del foro vi è la possibilità di predisporre una fioriera dotata di un dispositivo di riserva d’acqua integrato che garantisce un giusto grado di umidità del terreno evitando che tutta l’acqua immessa all’interno si disperda."; Descrizione Tecnica per Codice: PANCA OLIMPO S IN GRANITO (COLORE A SCELTA) LEVIGATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: Bench model "OLIMPO S", consisting of a circular monolithic seat equipped with a backrest and a central through-hole for the arrangement of not only flowers but also plants with stems. Inside the hole, there is the option to place a planter with an integrated water reservoir device that ensures proper soil moisture, preventing the complete dispersion of water added inside.; Technical Description for Article: OLIMPO S BENCH IN GRANITO (COLOR TO BE CHOSEN) POLISHED ANTI-DECAY VARNISH
Type - Materiali e finiture - MATERIALE ANELLO: Acciaio; Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; MATERIALE SEDUTA: GRANITO LEVIGATO; Primary Material: White granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 3383 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR081 - GRANITO -733 Lt
Altro - Famiglia: Panca OLIMPO S: 0PAAR081 - GRANITO -733 Lt; Famiglia e tipo: Panca OLIMPO S: 0PAAR081 - GRANITO -733 Lt; ID tipo: Panca OLIMPO S: 0PAAR081 - GRANITO -733 Lt; Tipo: Panca OLIMPO S: 0PAAR081 - GRANITO -733 Lt
Dimensioni - Area: 10.2611 m2; Volume: 1.81029 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
